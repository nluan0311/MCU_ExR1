# Keil uVision project Round1_FPGA.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: SN32F407F SONiX
  pack: SONiX.SN32F4_DFP.1.0.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Round1_FPGA
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Lib
    ./Lib/segment/: segment.c segment.h
    ./Lib/button/: button.c button.h
  group Main
    ./main/: main.c
